<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADS129x_3V3_STM32L151.ewp</path>
  </project>
  <batchBuild />
</workspace>
